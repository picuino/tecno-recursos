File: source/neumatic/simbolos-nombres/neumatic-simbolos.kicad_sch (KiCad schematic)
At the start: 83 parts

Commit message: 10/04/2024 Update
Connections:
- new net: V?., V?.
